# Keil uVision project GPS_chuankou2.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: GPS_chuankou2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 GPS_chuankou2.c GPS_chuankou2_GPS_init.c
